Commit message: added the body frame FO derivs

File: models/2link.urdf (robot description, URDF)
Before this commit: robot 2link, 3 links, 2 joints
Links:
- link link1: mass 1.5 -> 1.0
- link link2: mass 1.5 -> 1.0
